# Keil uVision project Printf.uvprojx, settings and files
target Printf (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: AT32F421C8T7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.4
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: Template
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F421C8T7,USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,AT_START_F421_V1_0
  c include: ..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM4\CoreSupport;..\Libraries\CMSIS\CM4\DeviceSupport;..\AT32_Board
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group USER
    ../USER/: main.c at32f4xx_it.c myADC.c
  group BSP
    ../AT32_Board/: at32_board.c
  group CMSIS
    ../USER/: system_at32f4xx.c
    ../Libraries/CMSIS/CM4/DeviceSupport/: startup_at32f421c8t7.s
  group AT32Periph
    ../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_gpio_ex.c at32f4xx_rcc.c at32f4xx_usart.c at32f4xx_adc.c at32f4xx_dma.c misc.c
  group README
    ../USER/: readme.txt
